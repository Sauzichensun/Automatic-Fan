# Keil uVision project projiect.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: projiect
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s system_stm32f10x.c system_stm32f10x.h stm32f10x.h core_cm3.h core_cm3.c
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h MyRTC.c MyRTC.h MyBKP.c MyBKP.h
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h FAN.c FAN.h ScanKey.c ScanKey.h Servo.c Servo.h LED.c LED.h TEMP.c TEMP.h BLUETOOTH.c BLUETOOTH.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
